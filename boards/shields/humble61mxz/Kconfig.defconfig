## boards/shields/humble61mxz/Kconfig.defconfig
```kconfig
if SHIELD_HUMBLE61MXZ

config ZMK_KEYBOARD_NAME
    default "humble61mxz"

endif
```
